# Keil uVision project Oscilloscope.uvprojx, settings and files
target Oscilloscope (6240000::V6.24::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Oscilloscope +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\CMSIS\Include;..\CMSIS\Device\Include;..\STM32F1xx_HAL_Driver\Inc;..\User;..\Drivers\Inc;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable;..\Middlewares\FreeRTOS\userTask;..\Middlewares\LVGL\lvgl;..\Middlewares\LVGL\lvgl_app;..\Middlewares\LVGL\lvgl\porting;..\Middlewares\LVGL\lvgl\src\core;..\Middlewares\LVGL\lvgl\src\display;..\Middlewares\LVGL\lvgl\src\draw;..\Middlewares\LVGL\lvgl\src\drivers;..\Middlewares\LVGL\lvgl\src\font;..\Middlewares\LVGL\lvgl\src\indev;..\Middlewares\LVGL\lvgl\src\layouts;..\Middlewares\LVGL\lvgl\src\layouts\flex;..\Middlewares\LVGL\lvgl\src\layouts\grid;..\Middlewares\LVGL\lvgl\src\libs\barcode;..\Middlewares\LVGL\lvgl\src\libs\bin_decoder;..\Middlewares\LVGL\lvgl\src\libs\bmp;..\Middlewares\LVGL\lvgl\src\libs\ffmpeg;..\Middlewares\LVGL\lvgl\src\libs\freetype;..\Middlewares\LVGL\lvgl\src\libs\fsdrv;..\Middlewares\LVGL\lvgl\src\misc;..\Middlewares\LVGL\lvgl\src\osal;..\Middlewares\LVGL\lvgl\src\others;..\Middlewares\LVGL\lvgl\src\stdlib;..\Middlewares\LVGL\lvgl\src\themes;..\Middlewares\LVGL\lvgl\src\tick;..\Middlewares\LVGL\lvgl\src\widgets;..\Middlewares\ff15\exfuns;..\Middlewares\ff15\source
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/Device/arm/: startup_stm32f103xe.s
    ../CMSIS/Device/: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group User
    ../User/: main.c stm32f1xx_it.c
  group Drivers
    ../Drivers/Src/: systemclock.c delay.c uart.c button.c lcd.c lcd_ex.c touch.c timer.c adc_sample.c oscilloscope.c 24cxx.c iic.c
